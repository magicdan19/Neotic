Commit message: main

File: AGX/catkin_ws/src/tondeuse_description/sdf/tondeuse.urdf (robot description, URDF)
Before this commit: robot sam_bot, 6 links, 5 joints
Joints:
- joint camera_joint: origin xyz=0.12 0 0.09 rpy=0 0 0 -> xyz=0.135 0 0.11 rpy=0 0 0
